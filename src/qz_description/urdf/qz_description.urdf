Commit message: add visual for robot base

File: src/qz_description/urdf/qz_description.urdf (robot description, URDF)
Before this commit: robot qingzhui, 3 links, 2 joints
Links:
- link base_link: geometry visual box size=1.2 0.8 0.4
